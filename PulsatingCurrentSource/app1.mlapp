classdef app1 < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        UIFigure                      matlab.ui.Figure
        UpdatePWMButton               matlab.ui.control.Button
        UpdateDACButton               matlab.ui.control.Button
        StartStopButton               matlab.ui.control.StateButton
        ConnecttoDelfinoButton        matlab.ui.control.Button
        CurrentPropertiesPanel        matlab.ui.container.Panel
        DACVoltageSETVEditFieldLabel  matlab.ui.control.Label
        DACVoltageSETVEditField       matlab.ui.control.NumericEditField
        CurrentAmplitudemALabel       matlab.ui.control.Label
        CurrentAmplitudemAEditField   matlab.ui.control.NumericEditField
        CurrentPulsePanel             matlab.ui.container.Panel
        SETEditField_2Label           matlab.ui.control.Label
        SETEditField_2                matlab.ui.control.NumericEditField
        SETEditFieldLabel             matlab.ui.control.Label
        SETEditField                  matlab.ui.control.NumericEditField
        OperatingModeSwitch           matlab.ui.control.Switch
        OperatingModeSwitchLabel      matlab.ui.control.Label
        DutyCyclyLabel                matlab.ui.control.Label
        DutyCyclyEditField            matlab.ui.control.NumericEditField
        FrequencyHzEditFieldLabel     matlab.ui.control.Label
        FrequencyHzEditField          matlab.ui.control.NumericEditField
        ResistorValuesPanel           matlab.ui.container.Panel
        R_2OhmEditFieldLabel          matlab.ui.control.Label
        R_2OhmEditField               matlab.ui.control.NumericEditField
        R_1OhmEditFieldLabel          matlab.ui.control.Label
        R_1OhmEditField               matlab.ui.control.NumericEditField
        R_0OhmEditField               matlab.ui.control.NumericEditField
        R_0OhmLabel                   matlab.ui.control.Label
        Image                         matlab.ui.control.Image
        PulsatingCurrentSourceLabel   matlab.ui.control.Label
    end

    
    properties (Access = private)
        %% Delfino
        delfino % serial port object
        delfinoReady = false;
        delfinoCommands = {'TEST', 'RUNDAC', 'KILLDAC', 'RUNPWM', 'KILLPWM', ...
            'PWMDUTY', 'PWMFREQ', 'RUNPWMSINGLE'}

        %% PWM
        frequency;
        duty;

        %% DAC
        dacValue = 0.0;

    end


    % Callbacks that handle component events
    methods (Access = private)

        % Button pushed function: ConnecttoDelfinoButton
        function ConnecttoDelfinoButtonPushed(app, event)
            try
                if(~app.delfinoReady)
                    disp(app.delfinoCommands(1))
                    % Define a serial port object.
                    app.delfino = serialport('/dev/cu.usbserial-TI65TN5T1', 9600);

                    % connect to controller
                    fopen(app.delfino);

                    % test connection
                    fprintf(app.delfino, app.delfinoCommands{1});
                    strIn = fscanf(app.delfino, '%s\n');

                    if (strcmp(strIn, 'PASSED'))
                        app.ConnecttoDelfinoButton.BackgroundColor = [0 1 0];
                        app.delfinoReady = true;
                    else
                        app.ConnecttoDelfinoButton.BackgroundColor = [1 1 1];
                        app.delfinoReady = false;
                        fclose(app.delfino);
                    end
                else
                    app.ConnecttoDelfinoButton.BackgroundColor = [1 1 1];
                    app.delfinoReady = false;
                    fclose(app.delfino);
                end
            catch
            end
        end

        % Value changed function: StartStopButton
        function StartStopButtonValueChanged(app, event)
            value = app.StartStopButton.Value;

            %Get the values that are needed in order to calaculate the voltage of the ADC 
            r0 = app.R_0OhmEditField.Value;
            r1 = app.R_1OhmEditField.Value;
            r2 = app.R_2OhmEditField.Value;
            %The current ampltiude is given in mA
            i = app.CurrentAmplitudemAEditField.Value;

            %Calculate the DAC voltage
            app.dacValue = (i / 1000) * r0 * (r1 / r2);

            %Now convert the DAC Value to a number from the intervall [0; 4095]
            app.dacValue = round(((4096 / 3) * app.dacValue) - 1);

            %Get the desired frequency and duty cycle
            app.frequency = app.FrequencyHzEditField.Value;
            app.duty = app.DutyCyclyEditField.Value;
            
            if (value == 1)              
                % determine the operation mode of the PWM unit
                switch app.OperatingModeSwitch.Value
                    case 'Single'
                        try
                            % send the dac value
                            fprintf(app.delfino, app.delfinoCommands{2});
                            fprintf(app.delfino, string(app.dacValue));
                            app.DACVoltageSETVEditField.Value = str2double(fscanf(app.delfino, '%s\n')) * (3 / 4096);

                            % send the PWM frequency
                            fprintf(app.delfino, app.delfinoCommands{7});
                            fprintf(app.delfino, string(app.frequency));
                            app.SETEditField.Value = str2double(fscanf(app.delfino, '%s\n'));
                
                            % send the PWM duty cycle
                            fprintf(app.delfino, app.delfinoCommands{6});
                            fprintf(app.delfino, string(app.duty));
                            app.SETEditField_2.Value = str2double(fscanf(app.delfino, '%s\n'));

                            % start the PWM - SINGLE mode only
                            fprintf(app.delfino, app.delfinoCommands{8});
                        catch
                        end
                    case 'Continuous'
                        try
                            % send the dac value
                            fprintf(app.delfino, app.delfinoCommands{2});
                            fprintf(app.delfino, string(app.dacValue));
                            app.DACVoltageSETVEditField.Value = str2double(fscanf(app.delfino, '%s\n')) * (3 / 4096);

                            % send the PWM frequency
                            fprintf(app.delfino, app.delfinoCommands{7});
                            fprintf(app.delfino, string(app.frequency));
                            app.SETEditField.Value = str2double(fscanf(app.delfino, '%s\n'));
                
                            % send the PWM duty cycle
                            fprintf(app.delfino, app.delfinoCommands{6});
                            fprintf(app.delfino, string(app.duty));
                            app.SETEditField_2.Value = str2double(fscanf(app.delfino, '%s\n'));

                            % start the PWM
                            fprintf(app.delfino, app.delfinoCommands{4});
                        catch
                        end
                end
            else
                try
                    % send the DAC kill command
                    fprintf(app.delfino, app.delfinoCommands{3});
        
                    % send the PWM kill command
                    fprintf(app.delfino, app.delfinoCommands{5});
                catch
                end
            end       
        end

        % Button pushed function: UpdateDACButton
        function UpdateDACButtonPushed(app, event)
            %Get the values that are needed in order to calaculate the voltage of the ADC 
            r0 = app.R_0OhmEditField.Value;
            r1 = app.R_1OhmEditField.Value;
            r2 = app.R_2OhmEditField.Value;
            %The current ampltiude is given in mA
            i = app.CurrentAmplitudemAEditField.Value;

            %Calculate the DAC voltage
            app.dacValue = (i / 1000) * r0 * (r1 / r2);

            %Now convert the DAC Value to a number from the intervall [0; 4095]
            app.dacValue = round(((4096 / 3) * app.dacValue) - 1);
            try
                % send the dac value
                fprintf(app.delfino, app.delfinoCommands{2});
                fprintf(app.delfino, string(app.dacValue));
                app.DACVoltageSETVEditField.Value = str2double(fscanf(app.delfino, '%s\n')) * (3 / 4096);
            catch
            end
        end

        % Button pushed function: UpdatePWMButton
        function UpdatePWMButtonPushed(app, event)
            app.frequency = app.FrequencyHzEditField.Value;
            app.duty = app.DutyCyclyEditField.Value;

            try
                % send the PWM frequency
                fprintf(app.delfino, app.delfinoCommands{7});
                fprintf(app.delfino, string(app.frequency));
                app.SETEditField.Value = str2double(fscanf(app.delfino, '%s\n'));

                % send the PWM duty cycle
                fprintf(app.delfino, app.delfinoCommands{6});
                fprintf(app.delfino, string(app.duty));
                app.SETEditField_2.Value = str2double(fscanf(app.delfino, '%s\n'));
            catch
            end
        end
    end

    % Component initialization
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            % Get the file path for locating images
            pathToMLAPP = fileparts(mfilename('fullpath'));
            app.UIFigure = uifigure('Visible', 'off');
            app.UIFigure.Name = 'MATLAB App';
            app.PulsatingCurrentSourceLabel = uilabel(app.UIFigure);
            app.PulsatingCurrentSourceLabel.Text = 'Pulsating Current Source';
            app.ResistorValuesPanel = uipanel(app.UIFigure);
            app.ResistorValuesPanel.Title = 'Resistor Values';
            app.Image = uiimage(app.ResistorValuesPanel);
            app.Image.ImageSource = fullfile(pathToMLAPP, 'CurrentSourceCircuit.png');
            app.R_0OhmLabel = uilabel(app.ResistorValuesPanel);
            app.R_0OhmLabel.Text = 'R_0 (Ohm)';
            app.R_0OhmEditField = uieditfield(app.ResistorValuesPanel, 'numeric');
            app.R_0OhmEditField.Value = 15;
            app.R_1OhmEditField = uieditfield(app.ResistorValuesPanel, 'numeric');
            app.R_1OhmEditField.Value = 10000;
            app.R_1OhmEditFieldLabel = uilabel(app.ResistorValuesPanel);
            app.R_1OhmEditFieldLabel.Text = 'R_1 (Ohm)';
            app.R_2OhmEditField = uieditfield(app.ResistorValuesPanel, 'numeric');
            app.R_2OhmEditField.Value = 1000;
            app.R_2OhmEditFieldLabel = uilabel(app.ResistorValuesPanel);
            app.R_2OhmEditFieldLabel.Text = 'R_2 (Ohm)';
            app.CurrentPropertiesPanel = uipanel(app.UIFigure);
            app.CurrentPropertiesPanel.Title = 'Current Properties';
            app.CurrentPulsePanel = uipanel(app.CurrentPropertiesPanel);
            app.CurrentPulsePanel.Title = 'Current Pulse';
            app.FrequencyHzEditField = uieditfield(app.CurrentPulsePanel, 'numeric');
            app.FrequencyHzEditField.Value = 5000;
            app.FrequencyHzEditFieldLabel = uilabel(app.CurrentPulsePanel);
            app.FrequencyHzEditFieldLabel.Text = 'Frequency (Hz)';
            app.DutyCyclyEditField = uieditfield(app.CurrentPulsePanel, 'numeric');
            app.DutyCyclyEditField.Value = 50;
            app.DutyCyclyLabel = uilabel(app.CurrentPulsePanel);
            app.DutyCyclyLabel.Text = 'Duty Cycly (%)';
            app.OperatingModeSwitchLabel = uilabel(app.CurrentPulsePanel);
            app.OperatingModeSwitchLabel.Text = 'Operating Mode';
            app.OperatingModeSwitch = uiswitch(app.CurrentPulsePanel, 'slider');
            app.OperatingModeSwitch.Items = {'Single', 'Continuous'};
            app.OperatingModeSwitch.Value = 'Single';
            app.SETEditField = uieditfield(app.CurrentPulsePanel, 'numeric');
            app.SETEditField.Limits = [0 Inf];
            app.SETEditField.Editable = 'off';
            app.SETEditFieldLabel = uilabel(app.CurrentPulsePanel);
            app.SETEditFieldLabel.Text = 'SET';
            app.SETEditField_2 = uieditfield(app.CurrentPulsePanel, 'numeric');
            app.SETEditField_2.Limits = [0 Inf];
            app.SETEditField_2.Editable = 'off';
            app.SETEditField_2Label = uilabel(app.CurrentPulsePanel);
            app.SETEditField_2Label.Text = 'SET';
            app.CurrentAmplitudemAEditField = uieditfield(app.CurrentPropertiesPanel, 'numeric');
            app.CurrentAmplitudemAEditField.Limits = [0 20];
            app.CurrentAmplitudemALabel = uilabel(app.CurrentPropertiesPanel);
            app.CurrentAmplitudemALabel.Text = {'Current '; 'Amplitude (mA)'};
            app.DACVoltageSETVEditField = uieditfield(app.CurrentPropertiesPanel, 'numeric');
            app.DACVoltageSETVEditField.Limits = [0 Inf];
            app.DACVoltageSETVEditField.Editable = 'off';
            app.DACVoltageSETVEditFieldLabel = uilabel(app.CurrentPropertiesPanel);
            app.DACVoltageSETVEditFieldLabel.Text = {'DAC Voltage '; 'SET (V)'};
            app.ConnecttoDelfinoButton = uibutton(app.UIFigure, 'push');
            app.ConnecttoDelfinoButton.ButtonPushedFcn = createCallbackFcn(app, @ConnecttoDelfinoButtonPushed, true);
            app.ConnecttoDelfinoButton.Text = 'Connect to Delfino';
            app.StartStopButton = uibutton(app.UIFigure, 'state');
            app.StartStopButton.ValueChangedFcn = createCallbackFcn(app, @StartStopButtonValueChanged, true);
            app.StartStopButton.Text = 'Start/Stop';
            app.UpdateDACButton = uibutton(app.UIFigure, 'push');
            app.UpdateDACButton.ButtonPushedFcn = createCallbackFcn(app, @UpdateDACButtonPushed, true);
            app.UpdateDACButton.Text = 'Update DAC';
            app.UpdatePWMButton = uibutton(app.UIFigure, 'push');
            app.UpdatePWMButton.ButtonPushedFcn = createCallbackFcn(app, @UpdatePWMButtonPushed, true);
            app.UpdatePWMButton.Text = 'Update PWM';
            % Show the figure after all components are created
            app.UIFigure.Visible = 'on';
        end
    end

    % App creation and deletion
    methods (Access = public)

        % Construct app
        function app = app1

            % Create UIFigure and components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.UIFigure)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.UIFigure)
        end
    end
end